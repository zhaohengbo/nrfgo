# Keil uVision project gzll_device_w_dynamic_pairing_nrf24le1.uvproj, settings and files
target gazell device (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: gzll_device_w_dyn_pair_nrf24le1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: EX_PROJ_LE1
  c include: ..\..\..\..\..\hal;..\..\..\..\..\hal\nrf24l01p;..\..\..\..\..\gazell\common;..\..\..\..\..\gazell\nrf24le1;..\..\params;..\..\..\..\..\hal\nrf24le1;..\..\..\..\..\lib\assertions;..\..\..\..\..\compiler\common;..\..\..\..\..\compiler\c51
  link misc: REMOVEUNUSED
  group app
    ../: main.c
  group gzll
    ../../../../../gazell/nrf24le1/: gzll_timer_isr.c gzll_mcu.c gzll_radio_isr.c gzp_device_le1.c
    ../../../../../gazell/common/: gzp_device.c gzp.c gzll.c
  group hal
    ../../../../../hal/nrf24le1/: hal_nrf_hw.c hal_rtc.c hal_clk.c hal_flash.c hal_rng.c hal_aes.c
    ../../../../../hal/nrf24l01p/: hal_nrf.c
    ../../../../../hal/: hal_delay.c
