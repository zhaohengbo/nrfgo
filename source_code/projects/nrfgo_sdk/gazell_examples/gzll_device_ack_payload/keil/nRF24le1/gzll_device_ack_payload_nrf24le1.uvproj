# Keil uVision project gzll_device_ack_payload_nrf24le1.uvproj, settings and files
target gazell device (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: gzll_device_ack_payload_nrf24le1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\..\..\hal;..\..\..\..\..\..\hal\nrf24l01p;..\..\..\..\..\..\gazell\common;..\..\..\..\..\..\gazell\nrf24le1;..\..\..\params;..\..\..\..\..\..\hal\nrf24le1;..\..\..\..\..\..\lib\assertions;..\..\..\..\..\..\lib\crypt;..\..\..\..\..\..\compiler\c51;..\..\..\..\..\..\compiler\common
  link misc: REMOVEUNUSED
  group app
    ../../: main.c
  group gzll
    ../../../../../../gazell/nrf24le1/: gzll_timer_isr.c gzll_radio_isr.c gzll_mcu.c
    ../../../../../../gazell/common/: gzll.c
  group hal
    ../../../../../../hal/nrf24le1/: hal_nrf_hw.c hal_rtc.c hal_clk.c hal_aes.c hal_rng.c
    ../../../../../../hal/nrf24l01p/: hal_nrf.c
    ../../../../../../hal/: hal_delay.c
  group lib
    ../../../../../../lib/crypt/: lib_crypt.c lib_crypt_le1.c
