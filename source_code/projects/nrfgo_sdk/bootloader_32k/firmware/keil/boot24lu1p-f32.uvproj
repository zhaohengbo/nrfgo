# Keil uVision project boot24lu1p-f32.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: boot24lu1p-f32 +hex
  c flags: Optimize=9 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Application
    ../: main.c usb.c bootloader.c flash.c usb_desc_bootloader.c STARTUP.A51
